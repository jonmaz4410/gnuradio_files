options:
  parameters:
    author: Jonathan Mazurkiewicz
    description: packet transmit (for GNURadio 3.8.5)
    generate_options: no_gui
    id: pkt_xmt
    output_language: python
    title: pkt_xmt
  states: {}

blocks:
- name: SDR_ID
  id: variable
  parameters:
    value: '"ip:192.168.3.1"'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: buffer_size
  id: variable
  parameters:
    value: '0x8000'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2400000000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./input_csv.csv
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(42 ,[123, 39, 73, 68, 39, 58, 49, 44, 39, 109, 115, 103, 39, 58, 39, 104, 101, 108, 108, 111, 39, 44, 39, 116, 115, 39, 58, 50, 48, 50, 51, 48, 56, 48, 55, 49, 53, 53, 55, 48, 48, 125]))
    period: '100'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '32'
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_async_bb_1
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: gain
    auto_filter: 'True'
    bandwidth: bandwidth
    buffer_size: buffer_size
    cyclic: 'True'
    frequency: freq
    samplerate: samp_rate
    uri: SDR_ID
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0/((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: packet_format_gr38
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import array
      class blk(gr.sync_block):
          """Packet Format"""

          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Packet Format GR38",
                  in_sig = None,
                  out_sig = None)
              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out0'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)

          def handle_msg(self, msg):
              inMsg = pmt.to_python (msg)
              pld = inMsg[1] ## type-> numpy.ndarray
              mLen = len(pld)
              if (mLen > 0):
                  ## create a numpy array of type 'int' with preamble and sync word
                  tmp_char_list = np.array([85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,225,90,232,147],dtype=int)
                  ## append length 2x
                  tmp_char_list=np.append(tmp_char_list,(mLen >> 8))
                  tmp_char_list=np.append(tmp_char_list,(mLen & 255))
                  tmp_char_list=np.append(tmp_char_list,(mLen >> 8))
                  tmp_char_list=np.append(tmp_char_list,(mLen & 255))
                  tmp_char_list_len=len(tmp_char_list)
                  ## append original payload
                  new_char_list=np.insert(tmp_char_list,tmp_char_list_len,pld)
                  new_char_list_len=len(new_char_list)
                  ## save final numpy array as byte array (requires 'import array')
                  byte_array_new_char_list=array.array('B',new_char_list)
                  new_bytes_out_len = len(byte_array_new_char_list)
                  ## create PMT u8vector using byte array
                  new_out_bytes_pmt=pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(new_bytes_out_len,(byte_array_new_char_list)))
                  self.message_port_pub(pmt.intern('PDU_out0'), new_out_bytes_pmt)
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx1
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_message_strobe_0, strobe, digital_crc32_async_bb_1, in]
- [blocks_multiply_const_vxx_0, '0', mmse_resampler_xx_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', digital_constellation_modulator_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_1, '0']
- [blocks_tagged_stream_to_pdu_1, pdus, digital_crc32_async_bb_1, in]
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_0, '0']
- [digital_crc32_async_bb_1, out, packet_format_gr38, PDU_in]
- [mmse_resampler_xx_0, '0', iio_pluto_sink_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_sink_x_0, '0']
- [mmse_resampler_xx_0, '0', zeromq_pub_sink_0, '0']
- [packet_format_gr38, PDU_out0, blocks_pdu_to_tagged_stream_0, pdus]
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
